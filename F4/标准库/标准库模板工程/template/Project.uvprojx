# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx,HSE_VALUE =8000000
  c include: .\User;.\Startup;.\Startup\Core;.\Libraries\inc;.\Libraries\src;.\System\delay;.\System\sys;.\Bsp\led;.\Bsp\uart4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./Startup/: stm32f4xx.h system_stm32f4xx.h system_stm32f4xx.c
    ./Startup/Core/: startup_stm32f427_437xx.s core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group System
    ./System/delay/: delay.c delay.h
    ./System/sys/: sys.c
  group User
    ./User/: main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h main.h
  group Libraries
    ./Libraries/src/: stm32f4xx_fmpi2c.c stm32f4xx_dma2d.c stm32f4xx_can.c stm32f4xx_spi.c stm32f4xx_i2c.c stm32f4xx_gpio.c stm32f4xx_wwdg.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_spdifrx.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_rtc.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_hash_sha1.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_fmc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_crc.c stm32f4xx_cryp.c misc.c stm32f4xx_adc.c
    ./Libraries/inc/: stm32f4xx_usart.h stm32f4xx_wwdg.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_spi.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_iwdg.h stm32f4xx_lptim.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_gpio.h stm32f4xx_fmc.h stm32f4xx_fmpi2c.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_dma2d.h stm32f4xx_dcmi.h stm32f4xx_dfsdm.h stm32f4xx_dma.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_can.h misc.h stm32f4xx_adc.h
  group Bsp
    ./Bsp/led/: led.c
    ./Bsp/uart4/: uart4.c
